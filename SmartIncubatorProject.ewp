# IAR project SmartIncubatorProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: incubhatch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: .gitignore AGENTS.md README.md
  group Deployment
    ./: deploy_guide.md
  group Include
    ./: AlarmControl.h bsp.h Co2Control.h IncubatorHatcher.h MotorControl.h Priorities.h VentilationControl.h
  group QP
    ../../../../../../qp-7.32/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../../qp-7.32/qpc/src/qk/: qk.c
  group QP_PORT
    ../../../../../../qp-7.32/qpc/ports/arm-cm/qk/iar/: qk_port.c
  group QS
    ../../../../../../qp-7.32/qpc/src/qs/: qs.c qs_fp.c qs_rx.c qstamp.c
  group Source
    ./: AlarmControl.c bsp.c bsp_pwm.c Co2Control.c HatchMode.c HumidityControl.c LcdDisplay.c main.c MotorControl.c TemperatureControl.c VentilationControl.c
  group TM4C1294
    ./: Startup_TM4C1294NCPDT.s
